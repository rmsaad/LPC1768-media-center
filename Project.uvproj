# Keil uVision project Project.uvproj, settings and files
target LPC1700 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup code
    ./: startup_LPC17xx.s system_LPC17xx.c core_cm3.c
  group Source code
    ./: ADC.c GLCD_SPI_LPC1700.c IRQ.c KBD.c Project.c LED.c
  group Photos
    ./: dota.c ds.c mario.c
  group Audio Source files
    ./: adcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group Game Assets
    ./: boulder.c boulder_remove.c Bullet.c Bullet_remove.c Ship.c
